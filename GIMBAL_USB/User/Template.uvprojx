# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: zero
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4,USE_USB_OTG_FS
  c include: ..\User;..\System\include;..\System\Core;..\System\CMSIS;..\System\FWLib\inc;..\System\FreeRTOS\include;..\System\FreeRTOS\CMSIS_RTOS;..\System\FreeRTOS\portable\RVDS\ARM_CM4F;..\Drivers\RC;..\Drivers\CAN;..\Drivers\USART;..\Devices\LED;..\Devices\RemoteControl;..\MPU;..\Task\Detect;..\Task\CAN;..\Task\Gimbal;..\Task\Chassis;..\Task\Shoot;..\Task\Judge;..\Algorithm;..\Algorithm\PID;..\Algorithm\User_Lib;..\Task\TX2;..\Algorithm\Ramp;..\Drivers\TIMER;..\Algorithm\ADRC;..\USB\STM32_USB_Device_Library\Class\cdc\inc;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_OTG_Driver\inc;..\USB\USB_APP;..\Algorithm\SmoothFilter
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group README
    ../: readme.txt
  group User
    ./: main.c
  group Task
    ../Task/Detect/: detect_task.c
    ../Task/Gimbal/: gimbal_task.c
    ../Task/TX2/: tx2_task.c
    ../Task/Chassis/: chassis_task.c
    ../Task/CAN/: CAN_receive.c
    ../Task/Shoot/: shoot_task.c
  group Devices
    ../Devices/LED/: LED.c
    ../Drivers/USART/: usart6.c usart1.c
    ../Devices/RemoteControl/: RemoteControl.c
  group Drivers
    ../Drivers/RC/: rc.c
    ../Drivers/CAN/: can.c
  group Algorithm
    ../Algorithm/PID/: pid.c
    ../Algorithm/User_Lib/: user_lib.c
    ../Algorithm/Ramp/: Ramp_Control.c
    ../Algorithm/SmoothFilter/: Smooth_Filter.c
    ../Algorithm/ADRC/: ADRC_core.c ADRC_user.c
  group Judge
    ../Task/Judge/: Judge_Task.c judgement_info.c protocol.c get_judge_measure.c
  group MPU
    ../MPU/: accelerometer_calibration.c BSP_Flash.c BSP_MPU9250_Init.c Filter_Control.c IMUTask.c mpu_delay.c MPU_SPI_Init.c MPU_TIME_Init.c arm_cortexM4lf_math.lib
  group System/include
    ../System/include/: sys.c delay.c
  group System/Core
    ../System/Core/: startup_stm32f40_41xxx.s
  group System/CMSIS
    ../System/CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group System/FWLib
    ../System/FWLib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group System/FreeRTOS_Core
    ../System/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../System/FreeRTOS/CMSIS_RTOS/: cmsis_os.c
  group System/FreeRTOS_Portable
    ../System/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../System/FreeRTOS/portable/MemMang/: heap_4.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_dcd.c usb_dcd_int.c usb_core.c
  group USB_DEVICE
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
